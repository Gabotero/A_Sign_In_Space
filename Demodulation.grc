options:
  parameters:
    author: Gabriel Otero Pérez
    description: Demodulation of TGO message
    generate_options: qt_gui
    id: Demod
    output_language: python
    title: A Sign in Space
  states: {}

blocks:
- name: PLL_BW_Hz
  id: variable
  parameters:
    value: '500'
  states: {}
- name: PLL_Limit_Hz
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: baudrate
  id: variable
  parameters:
    value: '52600'
  states: {}
- name: lowpass_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: samp_rate/200 * 0.8
    gain: '1.0'
    samp_rate: samp_rate
    width: samp_rate/200 * 0.1
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: samples_per_symbol
  id: variable
  parameters:
    value: samp_rate/baudrate
  states: {}
- name: subcarrier_freq
  id: variable
  parameters:
    value: 200000+63148
  states: {}
- name: syncword_bits
  id: variable
  parameters:
    value: 2*np.unpackbits(np.frombuffer(bytes.fromhex(syncword_hex), dtype = 'uint8')).astype('int')-1
  states: {}
- name: syncword_hex
  id: variable
  parameters:
    value: '''034776C7272895B0'''
  states: {}
- name: syncword_string
  id: variable
  parameters:
    value: '''''.join([str(i) for i in (syncword_bits+1)//2])'
  states: {}
- name: analog_pll_carriertracking_cc_0
  id: analog_pll_carriertracking_cc
  parameters:
    max_freq: PLL_Limit_Hz * 2 * pi / samp_rate
    min_freq: '-PLL_Limit_Hz * 2 * pi / samp_rate'
    w: PLL_BW_Hz * 2 * pi / samp_rate
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: subcarrier_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_real_0_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {state: disabled}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: final_decoded_frames.u8
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/gnuradio/Desktop/A_Sign_in_Space/recording/A_Sign_in_Space-GBT.sigmf-data
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    vector_input: 'False'
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_1
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    filter: '"sync_marker"'
    num_inputs: '2'
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: syncword_string
    tagname: '''sync_marker'''
    threshold: '4'
    type: float
  states: {}
- name: digital_correlate_access_code_tag_xx_0_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: syncword_string
    tagname: '''sync_marker'''
    threshold: '4'
    type: float
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: '0.001'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.01'
    max_dev: '0.01'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: samples_per_symbol
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: dslwp_ccsds_pseudo_randomizer_0
  id: dslwp_ccsds_pseudo_randomizer
  parameters:
    data_format: '3'
  states: {}
- name: dslwp_ccsds_turbo_decode_0
  id: dslwp_ccsds_turbo_decode
  parameters:
    base: '223'
    code_type: '2'
    iterations: '2'
    octets: '5'
    sigma: '0.707'
    update_sigma: '1'
  states: {}
- name: dslwp_frame_spliter_f_0
  id: dslwp_frame_spliter_f
  parameters:
    frame_length: '17848'
    key: '''sync_marker'''
  states: {}
- name: dslwp_frame_spliter_f_0_0
  id: dslwp_frame_spliter_f
  parameters:
    frame_length: '17848'
    key: '''sync_marker'''
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: np.ones(19)/19/1.25
    type: ccc
  states: {}
- name: fir_filter_xxx_1
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: syncword_bits[::-1]/syncword_bits.size
    type: fff
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: baudrate
    decim: '100'
    samp_rate: samp_rate
    taps: lowpass_taps
    type: ccc
  states: {state: disabled}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '65'
    win: firdes.WIN_HAMMING
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/200*0.8
    decim: '100'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: samp_rate/200*0.1
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    name: '"BPSK Constellation"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    name: '"BPSK Constellation"'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    label1: Before PLL
    label2: After PLL
    name: '"Visualizing the specturm"'
    nconnections: '2'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    label1: Real (I)
    label2: Imaginary (Q)
    name: '"I and Q components"'
    nconnections: '2'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_0_1_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate/100
    fc: '0'
    fftsize: '4096'
    name: '"Z[n] = y[n]y*[n-1] More res"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    label1: Baseband coarse
    label2: Baseband squared
    name: '"Side band"'
    nconnections: '2'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_1_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate/100
    fc: '0'
    fftsize: '4096'
    label1: Baseband decimated fine
    name: '"Side band squared decimated, fine tune"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_1_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    label1: Baseband coarse
    name: '"Z[n] = y[n]y*[n-1]"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: Samples
    label2: Correlation value
    marker1: '0'
    nconnections: '2'
    size: '100000'
    srate: baudrate
    style1: '0'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: Samples
    marker1: '0'
    size: '10000'
    srate: baudrate
    style1: '0'
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    label1: Before Filtering
    label2: After Matched Filter
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: satellites_rms_agc_0
  id: satellites_rms_agc
  parameters:
    alpha: '1e-5'
    reference: '1.0'
  states: {}

connections:
- [analog_pll_carriertracking_cc_0, '0', blocks_complex_to_float_0, '0']
- [analog_pll_carriertracking_cc_0, '0', blocks_complex_to_imag_0, '0']
- [analog_pll_carriertracking_cc_0, '0', qtgui_freq_sink_x_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_complex_to_float_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_complex_to_float_0, '1', qtgui_freq_sink_x_0_0, '1']
- [blocks_complex_to_imag_0, '0', hilbert_fc_0, '0']
- [blocks_complex_to_real_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_real_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [blocks_complex_to_real_0, '0', fir_filter_xxx_1, '0']
- [blocks_complex_to_real_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_complex_to_real_0_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_complex_to_real_0_0_0, '0', qtgui_time_sink_x_1, '1']
- [blocks_delay_0, '0', blocks_multiply_conjugate_cc_1, '1']
- [blocks_file_source_0, '0', blocks_interleaved_char_to_complex_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_complex_to_real_0_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_delay_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_multiply_conjugate_cc_1, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_multiply_xx_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_conjugate_cc_0, '0', fir_filter_xxx_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', qtgui_freq_sink_x_0_1, '0']
- [blocks_multiply_conjugate_cc_1, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [blocks_multiply_conjugate_cc_1, '0', qtgui_freq_sink_x_0_1_1, '0']
- [blocks_multiply_const_vxx_0, '0', digital_correlate_access_code_tag_xx_0_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0_1, '1']
- [blocks_pdu_to_tagged_stream_0, '0', blocks_file_sink_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', blocks_null_sink_0, '0']
- [blocks_throttle_0, '0', satellites_rms_agc_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', blocks_tag_debug_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', dslwp_frame_spliter_f_0_0, '0']
- [digital_correlate_access_code_tag_xx_0_0, '0', blocks_tag_debug_0, '1']
- [digital_correlate_access_code_tag_xx_0_0, '0', dslwp_frame_spliter_f_0, '0']
- [digital_costas_loop_cc_0, '0', blocks_complex_to_real_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_0_0, '0']
- [dslwp_ccsds_pseudo_randomizer_0, out, dslwp_ccsds_turbo_decode_0, in]
- [dslwp_ccsds_turbo_decode_0, out, blocks_pdu_to_tagged_stream_0, pdus]
- [dslwp_frame_spliter_f_0, out, dslwp_ccsds_pseudo_randomizer_0, in]
- [dslwp_frame_spliter_f_0_0, out, dslwp_ccsds_pseudo_randomizer_0, in]
- [fir_filter_xxx_0, '0', blocks_complex_to_real_0_0_0, '0']
- [fir_filter_xxx_0, '0', digital_symbol_sync_xx_0, '0']
- [fir_filter_xxx_1, '0', qtgui_time_sink_x_0, '1']
- [freq_xlating_fir_filter_xxx_0_0, '0', qtgui_freq_sink_x_0_0_0_1_0, '0']
- [hilbert_fc_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0_1_0, '0']
- [satellites_rms_agc_0, '0', analog_pll_carriertracking_cc_0, '0']
- [satellites_rms_agc_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
